# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6190000::V6.19::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F405xx, USE_HAL_DRIVER, HSE_VALUE="8000000", PLL_M="8"
  c misc: -Wno-date-time -Wno-unused-parameter -Wno-missing-variable-declarations -Wno-missing-noreturn
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc\Conf;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Kernel
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Test
    ./User/: main.c
software components: CMSIS:CORE 5.6.0
