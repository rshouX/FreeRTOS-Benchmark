# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6190000::V6.19::ARMCLANG)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RMP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: STM32L0xx, USE_HAL_DRIVER
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;.\Drivers\CMSIS\Include;.\Drivers\STM32L0xx_HAL_Driver\Inc;.\Drivers\STM32L0xx_HAL_Driver\Inc\Conf;.\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Kernel
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group Lib
    ./Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
    ./Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ./Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l071xx.s
  group Test
    ./User/: main.c
software components: CMSIS:CORE 5.6.0
